ENTRY(_start)
SECTIONS {
    . = 0x100000;  /* 부트로더가 로드되는 주소 */
    .text : AT(0x100000)
    {
        *(.text)
    }
    /* 다른 섹션들은 필요에 따라 추가할 수 있습니다. */
}
